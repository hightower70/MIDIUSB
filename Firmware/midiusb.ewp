# IAR project midiusb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; STM32F10X_MD; STM32F103C8
  ICCARM.CCIncludePath2: C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibMIDI\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\STM32F1xxCMSIS\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\STM32f1xxUSB\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\STM32F103MIDIUSBBoard\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: midiusb.srec
  ILINK.IlinkOutputFile: midiusb.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F103xB; STM32F10X_MD; STM32F103C8
  ICCARM.CCIncludePath2: C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibMIDI\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\STM32F1xxCMSIS\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\STM32f1xxUSB\Include; C:\Users\VladislavKorehov\Desktop\MIDIUSB-master\Firmware\LibOS\STM32F103MIDIUSBBoard\Include
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: midiusb.bin
  group (top)
    Source/: appMain.c
    EWARM/: startup_stm32f103xb.s
    LibOS/Source/: sysHelpers.c sysTimer.c
  group CMSIS
    LibOS/STM32F1xxCMSIS/Source/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group LibMIDI
    LibMIDI/Source/: midiEventQueue.c midiInput.c midiOutput.c midiUSB.c
  group STM32F103MIDIUSBBoard
    LibOS/STM32F103MIDIUSBBoard/Source/: halMain.c halMIDIPort.c halSystem.c halSystemTimer.c system_stm32f1xx.c
  group STM32f1xxUSB
    LibOS/STM32f1xxUSB/Source/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_midi.c usbd_midi_conf.c usbd_midi_desc.c
